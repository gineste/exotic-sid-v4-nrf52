# Keil uVision project Bootloader.uvprojx, settings and files
target BL_nRF52832 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Bootloader +hex
  AfterMake: ".\Output\MoveBootloader.bat"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NO_LED NO_BUTTON BLE_STACK_SUPPORT_REQD BOARD_CUSTOM NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0
  c include: RTE\Device\nRF52832_xxAA;Src\;Src\config;Src\components\ble\common;Src\components\boards;Src\components\drivers_nrf\clock;Src\components\drivers_nrf\common;Src\components\drivers_nrf\delay;Src\components\drivers_nrf\hal;Src\components\drivers_nrf\rng;Src\components\libraries\balloc;Src\components\libraries\bootloader;Src\components\libraries\bootloader\ble_dfu;Src\components\libraries\bootloader\dfu;Src\components\libraries\crc32;Src\components\libraries\crypto;Src\components\libraries\crypto\backend\micro_ecc;Src\components\libraries\crypto\backend\nrf_crypto_sw;Src\components\libraries\experimental_log;Src\components\libraries\experimental_log\src;Src\components\libraries\experimental_memobj;Src\components\libraries\experimental_section_vars;Src\components\libraries\fstorage;Src\components\libraries\hci;Src\components\libraries\mem_manager;Src\components\libraries\queue;Src\components\libraries\scheduler;Src\components\libraries\sha256;Src\components\libraries\strerror;Src\components\libraries\svc;Src\components\libraries\timer;Src\components\libraries\util;Src\components\softdevice\common;Src\components\softdevice\s132\headers;Src\components\softdevice\s132\headers\nrf52;Src\components\toolchain;Src\HAL;Src\ExoKey;Src\external\micro-ecc\micro-ecc;Src\external\nano-pb
  asm define: BLE_STACK_SUPPORT_REQD CUSTOM_BOARD CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SETTINGS_VERSION=1,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-D__HEAP_SIZE=0
  asm include: RTE\;Src\;Src\config;Src\components\ble\common;Src\components\boards;Src\components\drivers_nrf\clock;Src\components\drivers_nrf\common;Src\components\drivers_nrf\delay;Src\components\drivers_nrf\hal;Src\components\drivers_nrf\rng;Src\components\libraries\balloc;Src\components\libraries\bootloader;Src\components\libraries\bootloader\ble_dfu;Src\components\libraries\bootloader\dfu;Src\components\libraries\crc32;Src\components\libraries\crypto;Src\components\libraries\crypto\backend\micro_ecc;Src\components\libraries\crypto\backend\nrf_crypto_sw;Src\components\libraries\experimental_log;Src\components\libraries\experimental_log\src;Src\components\libraries\experimental_memobj;Src\components\libraries\experimental_section_vars;Src\components\libraries\fstorage;Src\components\libraries\hci;Src\components\libraries\mem_manager;Src\components\libraries\queue;Src\components\libraries\scheduler;Src\components\libraries\sha256;Src\components\libraries\strerror;Src\components\libraries\svc;Src\components\libraries\timer;Src\components\libraries\util;Src\components\softdevice\common;Src\components\softdevice\s132\headers;Src\components\softdevice\s132\headers\nrf52;Src\components\toolchain;Src\HAL;Src\ExoKey;Src\external\micro-ecc\micro-ecc;Src\external\nano-pb
  library: MicroLIB
  memory RVCT4: ROM 0x78000 size 0x6000
  memory RVCT9: RAM 0x20002180 size 0xde80
  link misc: --diag_suppress 6330
  group Application
    ./Src/Application/: main.c
  group Config
    ./Src/config/: sdk_config.h
    ./Src/components/boards/: boards.c
  group nRF_BLE
    ./Src/components/ble/common/: ble_srv_common.c
  group nRF_BLE_DFU
    ./Src/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ./Src/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ./Src/components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Crypto
    ./Src/components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group nRF_Crypto_Backends
    ./Src/components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ./Src/components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_Drivers
    ./Src/components/drivers_nrf/clock/: nrf_drv_clock.c
    ./Src/components/drivers_nrf/common/: nrf_drv_common.c
    ./Src/components/drivers_nrf/delay/: nrf_delay.h
    ./Src/components/drivers_nrf/rng/: nrf_drv_rng.c
    ./Src/components/drivers_nrf/hal/: nrf_nvmc.c
  group nRF_Libraries
    ./Src/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ./Src/components/libraries/scheduler/: app_scheduler.c
    ./Src/components/libraries/timer/: app_timer.c
    ./Src/components/libraries/crc32/: crc32.c
    ./Src/components/libraries/hci/: hci_mem_pool.c
    ./Src/components/libraries/mem_manager/: mem_manager.c
    ./Src/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ./Src/components/libraries/queue/: nrf_queue.c
    ./Src/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ./Src/components/libraries/strerror/: nrf_strerror.c
    ./Src/components/libraries/sha256/: sha256.c
  group nRF_SVC
    ./Src/components/libraries/svc/: nrf_svc_handler.c
    ./Src/components/libraries/bootloader/dfu/: nrf_dfu_svci_handler.c
  group nRF_SoftDevice
    ./Src/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ./Src/external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group HAL
    ./Src/HAL/: HAL_GPIO.c
  group ExoKey
    ./Src/ExoKey/: dfu_req_handling.c dfu-cc.pb.c public_key.c
  group nano-pb
    ./Src/external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.15.2
